	AREA CONCAT,CODE,READONLY
		LDR R0,=STR1
		LDR R1,=STR2
		MOV R3,#0	;INITIAL LENGTH OF FIRST STRING
		MOV R5,#0	;INITIAL LENGTH OF SECOND STRING
NEXT1	LDRB R2,[R0],#01	;CALCULATING STRING LENGTH OF FIRST STRING
		ADDS R3,#01
		CMP R2,#0
		BNE NEXT1
		SUBS R3,R3,#01
NEXT2	LDRB R4,[R1],#01	;CALCULATING STRING LENGTH OF SECOND STRING
		ADDS R5,#01
		CMP R4,#0
		BNE NEXT2
		SUBS R5,R5,#01
		LDR R0,=STR1
		LDR R1,=STR2
		LDR R9,=RESULTSTR	;PERFORMING STRING CONCATENATION
NEXT3	LDRB R10,[R1],#01	;ADDING FIRST STRING TO RESULTANT ARRAY
		STRB R10,[R9],#01
		SUBS R3,R3,#01
		BNE NEXT3		
NEXT4	LDRB R10,[R2],#01	;ADDING SECIND STRING TO RESULTANT ARRAY
		STRB R10,[R9],#01
		SUBS R5,R5,#01
		BNE NEXT4
		NOP
STR1 DCB "HELLO",0
STR2 DCB "WORLD",0
	AREA data1,DATA,READWRITE
RESULTSTR	DCB 0X0
	END