	AREA evenoddMerge,CODE,READONLY
		LDR R0,=ARR
		MOV R9,#10	;COUNT
		LDR R1,=EVENARR
		LDR R2,=ODDARR
		MOV R3,#0	;EVEN COUNT
		MOV R4,#0	;ODD COUNT
NEXT	LDR R5,[R0],#04
		MOV R6,R5
		MOVS R6,R6 ,LSR #01	;LEFT SHIFT BY ONE BIT
		BCS ODD
		ADD R3,R3,#1
		STR R5,[R1],#4
		B DEC
ODD		ADDS R4,R4,#01
		STR R5,[R2],#04
DEC		SUBS R9,R9,#01
		BNE NEXT
		LDR R1,=EVENARR
		LDR R2,=ODDARR
		LDR R10,=NEWARR
		MOV R9,R3
		MOV R8,R4
EVENADD LDR R11,[R1],#04
		STR R11,[R10],#04
		SUBS R9,R9,#01
		BNE EVENADD
ODDADD  LDR R11,[R2],#04
		STR R11,[R10],#04
		SUBS R8,R8,#01
		BNE ODDADD
		NOP
ARR DCD 0X1, 0X2, 0X3, 0X4, 0X5, 0X6, 0X7, 0X8, 0X9, 0X10
	AREA data1,DATA,READWRITE
EVENARR DCD 0X0, 0X0, 0X0, 0X0, 0X0
ODDARR DCD 0X0,0X0,0X0,0X0,0X0
NEWARR DCD 0X0,0X0,0X0,0X0,0X0
	END

